# Keil uVision project Project.uvprojx, settings and files
target STM32F4xx-Nucleo (6220000::V6.22::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4xx-Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE,USE_STM32F4XX_NUCLEO
  c misc: -std=c99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\MDK-ARM;..\..\STM32F4xx_HAL_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal_uart.h
  group Example/MDK-ARM
    ./: startup_stm32f411xe.s
    ./: app_config.h my_timer.c my_timer.h drv8313_io.c drv8313_io.h drv8313.c drv8313.h pwm_out.c pwm_out.h motor_sine_openloop.c motor_sine_openloop.h motor_ctrl.c motor_ctrl.h my_uart.c my_uart.h
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 6.1.0
